# Repository Christophe45/ESP32-Lorawan

File README.md:

# ESP32-Lorawan
ESP32 Lorawan beehive connected

This project is to make a connected hive that can control the weight, the internal and external temperature of the hive as well as the humidity. Data recovery is done with a Lora RFM95 module and reception of this data through a gateway connected to TTN. The data received on TTN is then sent to Node-red and sent back to Blynk's servers.

The schematic of the Lorawan is:

PCB 3D :

New version on test with a GPS module NOE6NV2 and an accelerometer MPU6050 used for alarm detection when the hive is moved.

schematic:

PCB 3D :

## KiCad design kicad lora node/lora node esp32 smd GPS.kicad_pcb

Parts:
C1, C2: 10µF; C_Elec_5x5.4
C3: 100nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.2mm_M2
J1: Conn_Coaxial_Power; SMA_Samtec_SMA-J-P-H-ST-EM1_EdgeMount
J2: Prog; PinSocket_1x04_P2.54mm_Vertical
J3: BME280 sensor; PinSocket_1x04_P2.54mm_Vertical
J4: solar connector; TerminalBlock_bornier-2_P5.08mm
J5: Battery; TerminalBlock_bornier-2_P5.08mm
J6: Load weight 200Kg; TerminalBlock_bornier-6_P5.08mm
J7: DS18B20; TerminalBlock_bornier-4_P5.08mm
J8: GPS NEO6MV2; PinHeader_1x04_P2.54mm_Vertical
J9: MPU-6050; PinSocket_1x08_P2.54mm_Vertical
J10: alarm button; TerminalBlock_bornier-2_P5.08mm
J11: load weight 2; TerminalBlock_bornier-2_P5.08mm
Q1: BC337; TO-92
R1, R3, R7: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R2: 2,7K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4: 1M; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5: 3M; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R6: 4.7K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1: RESET; SW_PUSH_6mm_H5mm
SW2: PROG; SW_PUSH_6mm_H5mm
U1: ESP32-WROOM-32
U2: RFM95W-868S2; HOPERF_RFM9XW_SMD
U3: MCP1700-3302E_TO92; TO-92
U4: TP4056; 4056E_LiIon_loader_SMT
U5: HX711; HX711 module
U6: MPU-6050; MPU6050
U7: GY-NEO6MV2; GY-NEO6

Connections:
/CheckVbat+: R4.2, R5.1, U1.8 (IO32)
/DS18: J7.2, R6.2, U1.9 (IO33)
/DT: U1.10 (IO25), U5.3 (DT)
/INT: J10.1, U1.6 (IO34)
/INT1: J9.8, J10.2, U6.8 (PIN)
/Prog: SW2.1, U1.25 (IO0)
/RX: J8.3, U1.26 (IO4), U7.3 (RX)
/RXD: J2.1, U1.35 (TXD0/IO1)
/SCL: J3.3, J9.3, U1.36 (IO22), U6.3 (SCL)
/SDA: J3.4, J9.4, U1.33 (IO21), U6.4 (SDA)
/SLK: U1.11 (IO26), U5.2 (SCK)
/TX: J8.2, U1.23 (IO15), U7.2 (TX)
/TXD: J2.2, U1.34 (RXD0/IO3)
/VBAT+: J5.2, R4.1, U4.3
/VBAT-: J5.1, U4.4
/Vin+: J4.1, U4.1
/Vin-: J4.2, U4.2
/deepsleep: J3.2, J7.3, J8.1, Q1.1 (C), R5.2, U2.1 (GND), U2.8 (GND), U2.10 (GND), U5.4 (GND), U7.1 (GND)
unnamed: C1.1, U3.2 (VI), U4.5
unnamed: J1.1 (In), U2.9 (ANT)
unnamed: J6.1, U5.5 (E+)
unnamed: J6.2, U5.6 (E-)
unnamed: J6.3, U5.7 (A-)
unnamed: J6.4, U5.8 (A+)
unnamed: J11.1, U5.9 (B-)
unnamed: J11.2, U5.10 (B+)
unnamed: Q1.2 (B), R2.2
unnamed: R1.2, SW1.2, U1.3 (EN)
unnamed: R2.1, R3.1, U1.27 (IO16)
unnamed: R7.1, U1.14 (IO12)
unnamed: U1.12 (IO27), U2.14 (DIO0)
unnamed: U1.13 (IO14), U2.15 (DIO1)
unnamed: U1.16 (IO13), U2.6 (RESET)
unnamed: U1.29 (IO5), U2.5 (NSS)
unnamed: U1.30 (IO18), U2.4 (SCK)
unnamed: U1.31 (IO19), U2.2 (MISO)
unnamed: U1.37 (IO23), U2.3 (MOSI)
VCC: C2.1, C3.2, C4.2, J2.3, J3.1, J7.1, J8.4, J9.1, R1.1, R6.1, U1.2 (VDD), U2.13 (3.3V), U3.3 (VO), U5.1 (VCC), U6.1 (VCC), U7.4 (VCC)

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
Board: 2 copper layers, 71.1 x 109.2 mm, 38 parts (0 on the bottom side), 39 nets.

## Commit log

2020-01-17 Create pictures
2020-01-17 first commit1
2020-01-20 Remove duplicated directory
2020-12-01 Create libraries
